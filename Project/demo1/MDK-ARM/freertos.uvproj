# Keil uVision project freertos.uvproj, settings and files
target freertos (ARM-ADS)
  device: STM32F205RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: freertos
  c flags: Optim=4 oTime=1
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,SERIAL_DEBUG
  c include: ..\inc;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\FreeRTOS\include;..\..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
    ../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    ../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group FreeRTOS
    ../../../FreeRTOS/: list.c queue.c tasks.c croutine.c
    ../../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../../../FreeRTOS/portable/MemMang/: heap_2.c
  group src
    ../src/: main.c serial_debug.c stm32f2xx_it.c
